## boards/shields/MySweep/Kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_MYSWEEP
    def_bool $(shields_list_contains,MySweep)
```
